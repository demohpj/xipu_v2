# Keil uVision project io.uvprojx, settings and files
target IO (6180000::V6.18::ARMCLANG)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: io +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group source
    ./: main.c flash.h flash.c font.h fs.h fs.c lcd.h lcd.c led.h led.c io.h io.c keyboard.h keyboard.c rs232.h rs232.c rtc.h rtc.c speaker.h speaker.c type.h usb.h usb.c
  group usbd
    ./USBD/: usbd_core.c usbd_core.h usbd_ctlreq.c usbd_ctlreq.h usbd_def.h usbd_ioreq.c usbd_ioreq.h usbd_msc.c usbd_msc.h usbd_msc_bot.c usbd_msc_bot.h usbd_msc_data.c usbd_msc_data.h usbd_msc_scsi.c usbd_msc_scsi.h usbd_storage_if.c usbd_storage_if.h usbd_conf.c usbd_conf.h usbd_desc.c usbd_desc.h
  group fatfs
    ./FatFs/: diskio.h ff.h ff_gen_drv.h integer.h diskio.c ff.c ff_gen_drv.c ffconf.h
software components: CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.6.0, Device:STM32Cube HAL:ADC 1.11.3, Device:STM32Cube HAL:COMMON 1.11.3, Device:STM32Cube HAL:CORTEX 1.11.3, Device:STM32Cube HAL:DAC 1.11.3, Device:STM32Cube HAL:DMA 1.11.3, Device:STM32Cube HAL:FLASH 1.11.3, Device:STM32Cube HAL:GPIO 1.11.3, Device:STM32Cube HAL:PCD 1.11.3, Device:STM32Cube HAL:RCC 1.11.3, Device:STM32Cube HAL:RTC 1.11.3, Device:STM32Cube HAL:SPI 1.11.3, Device:STM32Cube HAL:TIM 1.11.3, Device:STM32Cube HAL:UART 1.11.3, Device:STM32Cube HAL:USART 1.11.3, Device:Startup 1.0.0
